LICENSE="MIT"

inherit extrausers

EXTRA_USERS_PARAMS = " \
    usermod -p '\$1\$SomVbW5V\$qNv7uAZOFr.ivxNehP3DE1' root; \
"

