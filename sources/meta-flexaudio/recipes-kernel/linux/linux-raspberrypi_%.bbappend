
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


SRC_URI += " \
    file://rauc.cfg \
    "


ig nore s/